## boards/shields/chofu/Kconfig.deconfig
```kconfig
if ZMK_KEYBOARD_CHOFU

config ZMK_KEYBOARD_NAME
    default "chofu"

config ZMK_BLE
    default n

config ZMK_USB
    default y

endif
```
